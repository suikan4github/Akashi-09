# Repository suikan4github/Akashi-09

File README.md:

# Akashi-09
Prototype for [LI2026ODP](https://github.com/suikan4github/LI2026ODP).

## Jumper Configuration
- JP1 and JP2
  - 1-2 : Internal regulator
  - 2-3 : External Regulator
- JP3
  - Current measurement. Close it for normal usage.
## Base board configuration
Followings are the configuration of the STM32G0B1RE.
Pin | Function
----|----------
PA5 | SPI1_SCK
PA6 | LOAD
PA7 | SPI1_MOSI
PB0 | BLANK
PC5 | RKEY1
PC4 | RKEY2
PA10| RKEY3

## Caution
Cut the 3.3V regulator of the Nucleo to measure the current of the STM32G0B1RE. Thus the total current can be measured by JP3. 

## Other
- [Schematics](doc/Akashi-09.pdf)

## LICENSE
This board is licensed under [CC0](LICENSE).

## Photo

## KiCad design Akashi-09.kicad_pcb

Parts:
C1, C2: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4: 2.2uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10: D; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: 9-1437539-2
J2: Conn_01x03_Male; PinSocket_1x03_P2.54mm_Vertical
JP1, JP2: Jumper_3_Open; PinSocket_1x03_P2.54mm_Vertical
JP3: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
JP4, JP5: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
P1: Power; Socket_Strip_Arduino_1x08
P2: Analog; Socket_Strip_Arduino_1x06
P3: Digital; Socket_Strip_Arduino_1x10
P4: Digital; Socket_Strip_Arduino_1x08
P5, P6, P7, P8: CONN_01X01; Arduino_1pin
R1, R2, R3, R4, R5, R6, R7, R8, R9: 33k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10, R12, R14: 27k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R13, R15: 3.3k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_MEC_5G; SW_TH_Tactile_Omron_B3F-10xx
TP1, TP2: TestPoint; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
U1: max6921aui
U2: LT3008ETS8-3.3-TRPBF; LT3008ETS8-3.3-PBF

Connections:
+3V3: C2.1, D10.2 (A), JP2.2 (C), JP5.1 (A), TP2.1, U1.7 (VCC)
/+25V: J1.14, JP3.2 (B)
/BASE_3.3V: D10.1 (K), JP5.2 (B), P1.4
/BLANK: P3.8, U1.20 (BLANK)
/D_0: D1.1 (K), J1.2, R1.1
/D_1: D2.1 (K), J1.1, R2.1
/D_2: D3.1 (K), J1.28, R3.1
/D_3: D4.1 (K), J1.26, R4.1
/D_4: D5.1 (K), J1.25, R5.1
/D_5: D6.1 (K), J1.24, R6.1
/D_6: D7.1 (K), J1.23, R7.1
/D_7: D8.1 (K), J1.22, R8.1
/D_8: D9.1 (K), J1.21, R9.1
/KEY1: J1.17, R10.1
/KEY2: J1.18, R12.1
/KEY3: J1.19, R14.1
/LOAD: P3.6, U1.23 (LOAD)
/MOSI: P3.7, U1.6 (DIN)
/RKEY1: P4.8, R10.2, R11.1
/RKEY2: P4.7, R12.2, R13.1
/RKEY3: P4.6, R14.2, R15.1
/SCK: P3.5, U1.22 (CLK)
/SEG_A: J1.6, U1.3 (OUT2)
/SEG_B: J1.8, U1.5 (OUT0)
/SEG_C: J1.11, U1.12 (OUT17)
/SEG_D: J1.12, U1.13 (OUT16)
/SEG_DP: J1.13, U1.14 (OUT15)
/SEG_E: J1.10, U1.11 (OUT18)
/SEG_F: J1.7, U1.4 (OUT1)
/SEG_G: J1.9, U1.10 (OUT19)
/VBB: C1.1, JP1.2 (C), JP3.1 (A), U1.8 (VBB)
/nRESET: P1.3, SW1.3 (B), SW1.4 (B)
GND: C1.2, C2.2, C3.2, C4.2, J1.4, J2.2, P1.6, P1.7, P3.4, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2, R11.2, R13.2, R15.2, SW1.1 (A), SW1.2 (A), TP1.1, U1.21 (GND), U2.2 (GND), U2.3 (GND), U2.4 (GND)
unnamed: C3.1, JP4.2 (B), R16.1, U2.1 (*SHDN), U2.5 (IN)
unnamed: C4.1, JP2.1 (A), U2.6 (OUT), U2.7 (ADJ/SENSE)
unnamed: D1.2 (A), U1.2 (OUT3)
unnamed: D2.2 (A), U1.1 (OUT4)
unnamed: D3.2 (A), U1.28 (OUT5)
unnamed: D4.2 (A), U1.27 (OUT6)
unnamed: D5.2 (A), U1.26 (OUT7)
unnamed: D6.2 (A), U1.25 (OUT8)
unnamed: D7.2 (A), U1.24 (OUT9)
unnamed: D8.2 (A), U1.19 (OUT10)
unnamed: D9.2 (A), U1.18 (OUT11)
unnamed: J2.1, JP2.3 (B)
unnamed: J2.3, JP1.3 (B)
unnamed: JP1.1 (A), JP4.1 (A), R16.2

Notes on the sheet:
Holes
Shield for Arduino that uses the same pin disposition like "Uno" board Rev 3.
Note 1 : Short 1-2 of JP1 and JP2 to use on board regulator. Short 2-3 for external regulrator. Note 2: Install JP3 for normal use. Remove it for current measurement. Note 3 : R16 is for decoupling. If not needed, short JP4 Note 4 : Cut 3.3V of the base board.
1 : 3.3V In 2 : GND 3 : 25V out

Board: 2 copper layers, 68.6 x 53.3 mm, 50 parts (11 on the bottom side), 47 nets.

## Commit log

2022-02-06 Add license for CC zero.
2022-02-07 Layout done.
2022-02-08 Add test point
2022-02-08 Released gerber to manufacturer.
2022-10-11 Add images

Notices in the files:
parts and their libraries:
Copyright 2021 Accelerated Designs. All rights reserved.
